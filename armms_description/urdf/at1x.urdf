Commit message: add control node

File: armms_description/urdf/at1x.urdf (robot description, URDF)
Before this commit: robot at1x, 2 links, 1 joints
Joints:
- joint joint1: limit (none) -> lower=200.0 upper=260.0 effort=1.0 velocity=30.0
